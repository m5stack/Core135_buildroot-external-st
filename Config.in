## Config.in
```kconfig
source "$BR2_EXTERNAL_ST_PATH/package/m4projects/Config.in"
source "$BR2_EXTERNAL_ST_PATH/package/tinyalsa_custom/Config.in"
```
